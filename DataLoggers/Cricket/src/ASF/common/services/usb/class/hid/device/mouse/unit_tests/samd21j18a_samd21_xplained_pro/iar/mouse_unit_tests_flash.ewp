# IAR project mouse_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMD21_XPLAINED_PRO; _ASSERT_ENABLE_; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; USB_DEVICE_LPM_SUPPORT; USART_CALLBACK_MODE=true; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21; ../../../../../../../../../../sam0/drivers/port; ../..; ..; ../../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../../sam0/utils; ../../../../../../../../../../sam0/utils/cmsis/samd21/include/component; ../../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../../sam0/boards; ../../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../serial; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../../../sam0/drivers/system/interrupt; ../../..; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam0/utils/cmsis/samd21/include/pio; ../../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../../sam0/utils/cmsis/samd21/include/instance; ../../../..; ../../../../../../../../../boards; ../../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../../sam0/drivers/system; ../../../../../../../../../../sam0/drivers/extint; ../../../../..; ../../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_unit_tests_flash.bin
  ILINK.IlinkOutputFile: mouse_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c udi_hid_mouse.h udi_hid_mouse_conf.h
  group common/services/usb/class/hid/device/mouse/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/hid/device/mouse/unit_tests/samd21j18a_samd21_xplained_pro
    ../: conf_sleepmgr.h conf_board.h conf_test.h conf_clocks.h conf_extint.h
  group common/services/usb/class/hid/device/mouse/unit_tests/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../../serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group sam0/utils
    ../../../../../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21j18a.h samd21e17a.h samd21j16a.h samd21e18a.h samd21.h samd21e15a.h samd21g16a.h samd21e16a.h samd21g17a.h samd21j17a.h samd21g18a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../../../sam0/utils/cmsis/samd21/include/component/: component_eic.h component_pac.h component_ac.h component_dac.h component_sysctrl.h component_tc.h component_wdt.h component_rtc.h component_pm.h component_usb.h component_dmac.h component_mtb.h component_tcc.h component_adc.h component_nvmctrl.h component_evsys.h component_i2s.h component_dsu.h component_sercom.h component_gclk.h component_port.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: instance_sercom2.h instance_tcc2.h instance_sercom0.h instance_tc5.h instance_sercom1.h instance_tcc0.h instance_adc.h instance_tc6.h instance_i2s.h instance_pac1.h instance_nvmctrl.h instance_sercom4.h instance_tc4.h instance_tcc1.h instance_dmac.h instance_sercom5.h instance_dsu.h instance_rtc.h instance_eic.h instance_usb.h instance_dac.h instance_evsys.h instance_pm.h instance_sercom3.h instance_ac.h instance_wdt.h instance_sysctrl.h instance_mtb.h instance_gclk.h instance_tc7.h instance_port.h instance_pac0.h instance_tc3.h instance_pac2.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: pio_samd21g16a.h pio_samd21e17a.h pio_samd21j16a.h pio_samd21e18a.h pio_samd21j18a.h pio_samd21g18a.h pio_samd21j17a.h pio_samd21g17a.h pio_samd21e15a.h pio_samd21e16a.h
  group sam0/utils/stdio
    ../../../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../../../../sam0/utils/preprocessor/: preprocessor.h mrepeat.h mrecursion.h tpaste.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/extint
    ../../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.c extint.h extint_callback.h
  group sam0/drivers/extint/quick_start_polled
    ../../../../../../../../../../sam0/drivers/extint/quick_start_polled/: qs_extint_basic.h
  group sam0/drivers/extint/quick_start_callback
    ../../../../../../../../../../sam0/drivers/extint/quick_start_callback/: qs_extint_callback.h
  group sam0/drivers/sercom
    ../../../../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../../sam0/drivers/sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21
    ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/usb
    ../../../../../../../../../../sam0/drivers/usb/: usb.c usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_dual.c usb_device_udd.c usb_dual.h
